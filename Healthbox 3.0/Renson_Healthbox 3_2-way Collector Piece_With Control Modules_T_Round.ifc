Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-08T10:58:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 08 10:58:58 2023 * Host: RENSON-PCuyzIdp * Database: C:\Users\naniw\AppData\Local\Temp\{3426601E-B8BA-42C1-B153-662B54EBFBBB}\ifc * Database version: 5507 * Database creation date: Wed Mar 08 10:58:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 08 10:58:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 08 10:58:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowFitting: With Print, Renson_Healthbox 3_2-way Collector Piece_With Control Modules_T_Round:With Print:320822
In: Level 1
Type - PredefinedType: JUNCTION; Material: Color RGB 255-255-255, Color RGB 040-040-040
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DistributionFlowElementCommon - Reference: With Print
