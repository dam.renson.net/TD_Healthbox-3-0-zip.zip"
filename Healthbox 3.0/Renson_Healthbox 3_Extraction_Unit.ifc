Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-08T10:44:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 08 10:44:13 2023 * Host: RENSON-PCuyzIdp * Database: C:\Users\naniw\AppData\Local\Temp\{814BAB36-6C4F-4D2F-9ACD-E1BA252066AF}\ifc * Database version: 5507 * Database creation date: Wed Mar 08 10:44:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 08 10:44:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 08 10:44:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcDistributionControlElement: Bathroom Module, Renson_Healthbox 3_Control Unit_Control Module:Bathroom Module:322107
In: Level 1
Type - Classification: ﻿﻿ ​ ​ ​ ﻿ ​ ​ ﻿ ​ ​ ﻿ ​﻿ ​ ​ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 037-040-080, Color RGB 255-255-255, Color RGB 040-040-040
Pset_ManufacturerTypeInformation - Manufacturer: Renson

# IfcFlowController: Healthbox 3.0, Renson_Healthbox 3_Extraction_Unit:Healthbox 3.0:322106
In: Level 1
Type - Material: Color RGB 037-040-080, Color RGB 255-255-255
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DistributionFlowElementCommon - Reference: Healthbox 3.0

# IfcFlowFitting: 125-150, Renson_Healthbox 3_Reducer_Round_Exhaust Adapter 125-150:125-150:322108
In: Level 1
Type - PredefinedType: TRANSITION; Classification: ﻿﻿ ​ ​ ​ ﻿ ​ ​ ﻿ ​ ​ ﻿ ​﻿ ​ ​ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 037-040-080
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DistributionFlowElementCommon - Reference: 125-150

# IfcFlowFitting: 80-125 (7)
In: Level 1
Type - PredefinedType: TRANSITION; Classification: ﻿﻿ ​ ​ ​ ﻿ ​ ​ ﻿ ​ ​ ﻿ ​﻿ ​ ​ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 255-255-255
Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DistributionFlowElementCommon - Reference: 80-125
Name (Renson_Healthbox 3_Reducer_Round_Adapter 80-125:80-125:...)
322109
322110
322111
322112
322113
322114
322115
